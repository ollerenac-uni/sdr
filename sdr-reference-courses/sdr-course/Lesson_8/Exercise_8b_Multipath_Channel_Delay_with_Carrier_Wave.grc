options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: multipath_channel
    output_language: python
    title: Multipath Channel
  states: {}

blocks:
- name: amp_path_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Amp Path 0
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: amp_path_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Amp Path 1
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: amp_path_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Amp Path 2
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: delay_path_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay Path 0
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: delay_path_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Delay Path 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: delay_path_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Delay Path 2
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '3000'
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_per_sym_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: Samples/Symbol
    type: int
    value: samp_per_sym
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: sym_rate
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Symbol Rate
    type: real
    value: samp_rate/samp_per_sym
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_path_0
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_path_1
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_path_2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_path_0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_path_1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_path_2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./float(math.sqrt(amp_path_0**2+amp_path_1**2+amp_path_2**2))
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/4
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 5,1,1,1
    legend: 'False'
    name: Rx Spectrum
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,1,1,1
    legend: 'False'
    name: Tx Spectrum
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: Path 0
    label2: Path 1
    label3: Path 2
    name: Arriving Multipath
    nconnections: '3'
    size: int(samp_rate/500)
    srate: samp_rate
    style2: '2'
    style3: '4'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: At Ant
    name: Rx Signal
    size: int(samp_rate/500)
    srate: samp_rate
    type: float
  states: {}
- name: qtx_qam_waveform_passband_0
  id: qtx_qam_waveform_passband
  parameters:
    carrier_Freq: carrier_freq
    excess_BW: excess_bw
    sampleRate: samp_rate
    samplesPerSymbol: samp_per_sym
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_passband_0, '0']
- [qtx_qam_waveform_passband_0, '0', blocks_delay_0, '0']
- [qtx_qam_waveform_passband_0, '0', blocks_delay_0_0, '0']
- [qtx_qam_waveform_passband_0, '0', blocks_delay_0_0_0, '0']
- [qtx_qam_waveform_passband_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
