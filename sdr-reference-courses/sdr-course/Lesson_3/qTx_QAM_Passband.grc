options:
  parameters:
    author: Qasim Chaudhari
    category: '[qBlocks]'
    generate_options: hb
    id: qtx_qam_waveform_passband
    output_language: python
    title: QAM Waveform Passband
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: math.sqrt(2)
    comment: Local Oscillator Cosine
    freq: carrier_Freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-math.sqrt(2)'
    comment: Local Oscillator Sine
    freq: carrier_Freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: int(np.log2(4))
  states: {}
- name: carrier_Freq
  id: parameter
  parameters:
    label: Carrier Frequency
    type: eng_float
    value: '12000'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table I
    map: (1,-1,1,-1)
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table Q
    map: (1,1,-1,-1)
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    label: Excess Bandwidth
    type: eng_float
    value: '0.9'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Upsampler I
    interp: samp_per_sym
    taps: np.hstack((1,np.zeros(samp_per_sym-1)))
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Upsampler Q
    interp: samp_per_sym
    taps: (np.hstack((1,np.zeros(samp_per_sym-1))))
    type: fff
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Bits
    type: byte
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Pulse Shaping Filter I
    gain: samp_per_sym
    interp: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Pulse Shaping Filter Q
    gain: samp_per_sym
    interp: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_fff
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '8'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '8000'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', pad_sink_0_0, '0']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [interp_fir_filter_xxx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [pad_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '1']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
