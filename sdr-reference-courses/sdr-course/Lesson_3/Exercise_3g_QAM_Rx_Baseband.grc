options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: qam_rx_baseband
    output_language: python
    title: QAM Rx Baseband
  states: {}

blocks:
- name: downsample_delay
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: int
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: int
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: downsample_delay
    type: int
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: downsample_delay
    type: int
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Downsampler I
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Downsampler Q
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: Scatter Plot
    size: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,2,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    name: Downsampled I Arm
    size: '10'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    name: Downsampled Q Arm
    size: '10'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: ''
    legend: 'False'
    name: Matched Filtered Q Waveform
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: I
    label2: Q
    legend: 'False'
    name: Rx Waveform
    size: '200'
    srate: samp_rate
    type: complex
    width1: '2'
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: ''
    legend: 'False'
    name: Matched Filtered I Waveform
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    comment: Custom QAM Block
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter I
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter Q
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_float_0, '1', root_raised_cosine_filter_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_complex_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [qtx_qam_waveform_baseband_0, '0', blocks_complex_to_float_0, '0']
- [qtx_qam_waveform_baseband_0, '0', qtgui_time_sink_x_0_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_skiphead_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_2, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_skiphead_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
