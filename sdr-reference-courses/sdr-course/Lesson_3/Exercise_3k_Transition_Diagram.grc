options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: transition_diagram
    output_language: python
    title: Transition Diagram
  states: {}

blocks:
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    label: Excess BW
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.9'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    marker1: '-1'
    name: Transition Diagram
    size: '10000'
    style1: '1'
    type: complex
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [qtx_qam_waveform_baseband_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
