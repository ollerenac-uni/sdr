options:
  parameters:
    author: Qasim Chaudhari
    category: Custom
    generate_options: qt_gui
    id: costas_loop
    output_language: python
    title: Costas Loop
  states: {}

blocks:
- name: downsample_delay
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Loop Bandwidth
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: 2*math.pi/100.0
  states: {}
- name: phase_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Phase Offset
    orient: Qt.Horizontal
    start: '-math.pi'
    step: '0.05'
    stop: math.pi
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier Offset
    freq: freq_offset
    offset: '0'
    phase: phase_offset
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: downsample_delay
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    use_snr: 'True'
    w: loop_bw
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (1+excess_bw)*0.5*samp_rate/samp_per_sym-100
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: note_0_1
  id: note
  parameters:
    note: Downsampler
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    name: Costas Loop Out
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    color1: '"red"'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Input
    name: Before  Filter
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,1,1
    name: After  Filter
    size: '1024'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Phase
    label1: Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Frequency
    label2: Phase
    label3: Error
    name: Phase, Frequency and Error Signal
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: 2*math.pi
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}
- name: root_raised_cosine_filter_0_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter
    decim: '1'
    gain: '1'
    interp: samp_per_sym
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_keep_one_in_n_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_const_sink_x_0_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '1', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_0, '2', qtgui_time_sink_x_0, '1']
- [digital_costas_loop_cc_0, '3', qtgui_time_sink_x_0, '2']
- [low_pass_filter_0, '0', blocks_skiphead_0, '0']
- [qtx_qam_waveform_baseband_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0_0_0_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
