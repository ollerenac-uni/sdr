options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: mth_power
    output_language: python
    title: Mth Power
  states: {}

blocks:
- name: downsample_delay
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable_qtgui_chooser
  parameters:
    label: Excess Bandwidth
    label0: '1'
    label1: '0.5'
    label2: '0.1'
    num_opts: '3'
    option1: '0.5'
    option2: '0.1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {}
- name: phase_offset
  id: variable
  parameters:
    value: '-30*math.pi/180'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-math.pi'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    comment: Phase Error Detection
    exponent: '4'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Phase Rotation
    const: complex(math.cos(phase_offset),math.sin(phase_offset))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.25*180./math.pi
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: downsample_delay
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Downsampler
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,1,1,1
    legend: 'False'
    name: Scatter Plot
    size: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    marker2: '1'
    name: Downsampled Symbols
    size: '56'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    width1: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    name: Mth Power
    size: '56'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    comment: Custom QAM Block
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_exponentiate_const_cci_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_exponentiate_const_cci_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [qtx_qam_waveform_baseband_0, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
