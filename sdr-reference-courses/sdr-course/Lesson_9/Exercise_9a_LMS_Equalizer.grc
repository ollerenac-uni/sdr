options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: lms_equalizer
    output_language: python
    title: LMS Equalizer
  states: {}

blocks:
- name: equalizer_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Equalizer Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.02'
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: proakis_channel_a
  id: variable
  parameters:
    value: '[0.04, -0.05, 0.07, -0.21, -0.5, 0.72, 0.36, 0, 0.21, 0.03, 0.07]'
  states: {}
- name: proakis_channel_b
  id: variable
  parameters:
    value: '[0.407, 0.815, 0.407]'
  states: {}
- name: proakis_channel_c
  id: variable
  parameters:
    value: '[0.227, 0.46, 0.688, 0.46, 0.227]'
  states: {}
- name: proakis_channel_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Proakis Channel Chooser
    label0: Channel A
    label1: Channel B
    label2: Channel C
    num_opts: '3'
    option1: proakis_channel_b
    option2: proakis_channel_c
    orient: Qt.QHBoxLayout
    type: raw
    value: proakis_channel_a
    widget: radio_buttons
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: proakis_channel_chooser
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: proakis_channel_chooser
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: qpsk
    mu: equalizer_gain
    num_taps: '13'
    sps: samp_per_sym
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,1,1,1
    legend: 'False'
    name: Equalized Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    legend: 'False'
    name: Rx Constellation
    size: '1024'
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,1,1,1
    legend: 'False'
    name: Equalized Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: Rx Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,2,1,1
    legend: 'False'
    name: Tx and Channel Spectra
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: I
    label2: Q
    legend: 'False'
    name: Equalized Signal
    size: '150'
    srate: samp_rate
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: I
    label2: Q
    legend: 'False'
    name: Rx Signal
    size: '150'
    srate: samp_rate
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_1, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [blocks_throttle_1, '0', channels_channel_model_0_0, '0']
- [channels_channel_model_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_1, '1']
- [digital_lms_dd_equalizer_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', qtgui_time_sink_x_0, '0']
- [qtx_qam_waveform_baseband_0, '0', channels_channel_model_0, '0']
- [qtx_qam_waveform_baseband_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
