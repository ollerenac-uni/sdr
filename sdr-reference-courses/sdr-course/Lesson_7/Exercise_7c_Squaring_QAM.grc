options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: squaring_qam
    output_language: python
    title: Squaring a QAM Signal
  states: {}

blocks:
- name: excess_bw
  id: variable_qtgui_chooser
  parameters:
    label: Excess Bandwidth
    label0: '0.1'
    label1: '0.5'
    label2: '1'
    num_opts: '3'
    option1: '0.5'
    option2: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '0.1'
    widget: radio_buttons
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 1,1,1,1
    legend: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: ''
    legend: 'False'
    name: Product
    size: '300'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '4'
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [qtx_qam_waveform_baseband_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
