options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: polyphase_clock_sync
    output_language: python
    title: Polyphase Clock Sync
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Loop BW
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: 2*pi/10
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(samp_per_sym), excess_bw, 25*nfilts)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: timing_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0.97'
    step: '0.001'
    stop: '1.03'
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: timing_offset
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: Input Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    name: Output Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: I
    label2: Q
    legend: 'False'
    marker1: '0'
    marker2: '1'
    name: Input Samples
    size: 20*samp_per_sym
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: I
    label2: Q
    marker1: '0'
    marker2: '1'
    name: Output Samples
    size: '20'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: Error
    label2: Rate
    label3: Phase
    name: Diagnostics
    nconnections: '3'
    size: 10*samp_per_sym
    srate: samp_rate
    type: float
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '2', qtgui_time_sink_x_0_0_0, '1']
- [digital_pfb_clock_sync_xxx_0, '3', qtgui_time_sink_x_0_0_0, '2']
- [qtx_qam_waveform_baseband_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
