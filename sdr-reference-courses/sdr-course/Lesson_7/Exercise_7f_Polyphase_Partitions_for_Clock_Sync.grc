options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: polyphase_partitions_clock_sync
    output_language: python
    title: Polyphase Partitions for Clock Sync
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_eyes
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: excess_bw
    gain: upsampling_factor
    ntaps: 10*samp_per_sym*upsampling_factor+1
    samp_rate: samp_rate
    sym_rate: samp_rate/(samp_per_sym*upsampling_factor)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: timing_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: upsampling_factor-1
    value: '0'
  states: {}
- name: upsampling_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: ymax
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ymin
  id: variable
  parameters:
    value: '-2'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: timing_offset
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: upsampling_factor
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table
    map: (-1,1)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_taps[0::upsampling_factor]
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_taps[1::upsampling_factor]
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_taps[2::upsampling_factor]
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_taps[3::upsampling_factor]
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_filter[7::upsampling_factor]
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_filter[6::upsampling_factor]
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_filter[5::upsampling_factor]
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_filter[4::upsampling_factor]
    type: fff
  states: {state: disabled}
- name: qEye_0
  id: qEye
  parameters:
    eye_string: '''Child Filter 0'''
    gui_hint: 0,1,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate/upsampling_factor
    ymax: ymax
    ymin: ymin
  states: {}
- name: qEye_0_0
  id: qEye
  parameters:
    eye_string: '''Child Filter 3'''
    gui_hint: 1,2,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate/upsampling_factor
    ymax: ymax
    ymin: ymin
  states: {}
- name: qEye_0_0_0
  id: qEye
  parameters:
    eye_string: '''Child Filter 1'''
    gui_hint: 0,2,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate/upsampling_factor
    ymax: ymax
    ymin: ymin
  states: {}
- name: qEye_0_0_0_0
  id: qEye
  parameters:
    eye_string: '''Child Filter 2'''
    gui_hint: 1,1,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate/upsampling_factor
    ymax: ymax
    ymin: ymin
  states: {}
- name: qEye_0_0_0_0_0
  id: qEye
  parameters:
    eye_string: '''Child Filter 6'''
    gui_hint: 3,1,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
    ymax: ymax
    ymin: ymin
  states: {state: disabled}
- name: qEye_0_0_0_1
  id: qEye
  parameters:
    eye_string: '''Child Filter 5'''
    gui_hint: 2,2,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
    ymax: ymax
    ymin: ymin
  states: {state: disabled}
- name: qEye_0_0_1
  id: qEye
  parameters:
    eye_string: '''Child Filter 7'''
    gui_hint: 3,2,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
    ymax: ymax
    ymin: ymin
  states: {state: disabled}
- name: qEye_0_1
  id: qEye
  parameters:
    eye_string: '''PAM Eye'''
    gui_hint: 1,0,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate/upsampling_factor
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qEye_0_2
  id: qEye
  parameters:
    eye_string: '''Child Filter 4'''
    gui_hint: 2,1,1,1
    nEyes: n_eyes
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
    ymax: ymax
    ymin: ymin
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Pulse Shaping Filter
    gain: samp_per_sym*upsampling_factor
    interp: samp_per_sym*upsampling_factor
    ntaps: 10*samp_per_sym*upsampling_factor+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym/upsampling_factor
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter
    decim: '1'
    gain: '1'
    interp: samp_per_sym
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate/upsampling_factor
    sym_rate: samp_rate/samp_per_sym/upsampling_factor
    type: fir_filter_fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_delay_0, '0', blocks_skiphead_0, '0']
- [blocks_keep_one_in_n_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_keep_one_in_n_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_keep_one_in_n_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', interp_fir_filter_xxx_0_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [interp_fir_filter_xxx_0, '0', qEye_0, '0']
- [interp_fir_filter_xxx_0_0, '0', qEye_0_0_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', qEye_0_0_0_0, '0']
- [interp_fir_filter_xxx_0_0_0_0, '0', qEye_0_0, '0']
- [interp_fir_filter_xxx_0_0_0_0_0, '0', qEye_0_0_1, '0']
- [interp_fir_filter_xxx_0_0_0_1, '0', qEye_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0_0_1, '0', qEye_0_0_0_1, '0']
- [interp_fir_filter_xxx_0_1, '0', qEye_0_2, '0']
- [root_raised_cosine_filter_0, '0', blocks_delay_0, '0']
- [root_raised_cosine_filter_0_0, '0', qEye_0_1, '0']

metadata:
  file_format: 1
