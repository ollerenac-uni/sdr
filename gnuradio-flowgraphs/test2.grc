options:
  parameters:
    description: Reproduce una muestra I/Q sin hardware y conserva Soapy como fuente opcional.
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Sesión 01 - Lectura correcta de una muestra .cu8
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Frequency
    start: '24.9'
    step: '0.1'
    stop: '1800.9'
    value: '99.1'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: RF Gain (db)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {state: bypassed}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Fuente predeterminada sin hardware. Usa una muestra convertida de CU8 a complex64.
    file: ../samples/fm_99p1MHz_2p4Msps_g30.cu8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127.5
    type: float
  states: {state: bypassed}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Limita la reproducción a 2*samp_rate bytes por segundo, dos por muestra compleja. Desactivar junto con File Source cuando se use el dongle.
    samples_per_second: 2*samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq*M
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq*M
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    marker2: '1'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style2: '2'
    type: float
    ymax: '300'
    ymin: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq*M
    comment: Fuente alternativa con hardware. Para usarla, activar este bloque y desactivar File Source y Throttle.
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_deinterleave_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_deinterleave_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
