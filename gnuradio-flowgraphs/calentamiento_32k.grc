options:
  parameters:
    description: Lee el primer periodo del tono de 1 kHz a 32 kS/s desde un .cu8, sin hardware, y lo deja congelado en pantalla.
    generate_options: qt_gui
    id: calentamiento_32k
    output_language: python
    title: Laboratorio de muestreo - Calentamiento a 32 kS/s
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: En bypass para comparar los bytes con od; la guía lo quita al centrar y escalar.
    const: '-127.5'
    type: float
  states: {state: bypassed}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Lee solo los primeros 64 bytes: 32 muestras complejas, el primer periodo del tono. Con Repeat en No el flujo termina y los visores se quedan con esa imagen. Genera el archivo con: python samples/gen_tono.py'
    file: ../samples/tono_1kHz_32kSps.cu8
    length: '64'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: En bypass para comparar los bytes con od; la guía lo quita al centrar y escalar.
    const: 1/127.5
    type: float
  states: {state: bypassed}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Limita el flujo a 2*samp_rate bytes por segundo, dos por muestra compleja. Sin hardware que marque el ritmo, el archivo se leería a toda velocidad.
    samples_per_second: 2*samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32'
    label1: Espectro
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: I
    label2: Q
    marker1: '0'
    marker2: '1'
    size: '32'
    srate: samp_rate
    type: complex
    ymax: '256'
    ymin: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
