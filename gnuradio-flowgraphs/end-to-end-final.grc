options:
  parameters:
    author: oellc
    generate_options: qt_gui
    id: end_to_end_final
    output_language: python
    title: Enlace digital de mensajes
  states: {}

blocks:
- name: cierre_rx_muestras
  id: variable
  parameters:
    value: rrc_ntaps - 1
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: fase_grados
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: frecuencia_offset_hz
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: max_trama_bits
  id: variable
  parameters:
    value: max_trama_bytes * 8
  states: {}
- name: max_trama_bytes
  id: variable
  parameters:
    value: 5000 + 6 + len(sync_bytes) + 4
  states: {}
- name: offset_muestreo
  id: variable
  parameters:
    value: '0'
  states: {}
- name: reloj_ppm
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: retardo_muestras
  id: variable
  parameters:
    value: '0'
  states: {}
- name: retardo_total
  id: variable
  parameters:
    value: rrc_ntaps - 1
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_ntaps
  id: variable
  parameters:
    value: rrc_span * sps + 1
  states: {}
- name: rrc_span
  id: variable
  parameters:
    value: '8'
  states: {}
- name: ruido_amplitud
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: ruido_semilla
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: sync_bits
  id: variable
  parameters:
    value: '''''.join(format(b, ''08b'') for b in sync_bytes)'
  states: {}
- name: sync_bytes
  id: variable
  parameters:
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: a_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: cierre_rrc
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: rrc_span
    pre_padding: '0'
    type: complex
    window: ([1.0])
  states: {}
- name: cierre_rx
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: cierre_rx_muestras
    pre_padding: '0'
    type: complex
    window: ([1.0])
  states: {}
- name: constelacion_fase
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: vistas@1:2,0,1,2
    name: '"Muestras despues de Costas: incluye cierre"'
    size: '64'
    type: complex
  states: {}
- name: constelacion_rx
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: vistas@1:1,0,1,2
    name: '"Muestras a una por simbolo: incluye cierre"'
    size: '64'
    type: complex
  states: {}
- name: debug_deteccion
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: '"Paquetes detectados"'
    type: byte
  states: {}
- name: debug_invertida
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: '"Paquetes detectados: ruta invertida"'
    type: byte
  states: {}
- name: debug_muestras
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: debug_paquete_rx
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_rrc
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: debug_rx
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: debug_simbolos_rx
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: debug_sin_etiquetas
  id: blocks_tag_debug
  parameters:
    name: '"Entrada RX sin etiquetas"'
    type: complex
  states: {}
- name: debug_trama_tx
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: decidir_bits
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: desajustar_frecuencia
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*np.pi*frecuencia_offset_hz/samp_rate
  states: {}
- name: desajustar_reloj
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1/(1+reloj_ppm*1e-6)
    type: complex
  states: {}
- name: descartar_ted
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: detectar_invertida
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: sync_bits
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: detectar_trama
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: sync_bits
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: empaquetar_bits
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: empaquetar_invertida
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: envolver_trama
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.concatenate((np.array(sync_bytes + [len(x) >> 8, len(x) & 0xff] * 2, dtype=np.uint8), x))'
    metadict: Uniform Vector
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self, name="Texto a bytes UTF-8", in_sig=None, out_sig=None
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.convertir)

          def convertir(self, mensaje):
              # El cuadro de texto entrega un símbolo PMT.
              if not pmt.is_symbol(mensaje):
                  print("Texto a bytes: se esperaba un mensaje de texto.")
                  return

              texto = pmt.symbol_to_string(mensaje)
              datos = texto.encode("utf-8")

              # PDU: metadatos vacíos y vector de bytes.
              metadatos = pmt.make_dict()
              vector = pmt.init_u8vector(len(datos), list(datos))
              pdu = pmt.cons(metadatos, vector)

              self.message_port_pub(pmt.intern("out"), pdu)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self, name="Bytes a texto UTF-8", in_sig=None, out_sig=None
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.convertir)

          def convertir(self, mensaje):
              # La entrada debe ser una PDU con un vector de bytes.
              if not pmt.is_pdu(mensaje) or not pmt.is_u8vector(pmt.cdr(mensaje)):
                  print("Bytes a texto: se esperaba una PDU de bytes.")
                  return

              vector = pmt.cdr(mensaje)
              datos = bytes(pmt.u8vector_elements(vector))

              try:
                  texto = datos.decode("utf-8")
              except UnicodeDecodeError:
                  print("Bytes a texto: los bytes no forman un texto UTF-8 válido.")
                  return

              self.message_port_pub(pmt.intern("out"), pmt.intern(texto))
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import struct
      import zlib


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self, name="Construir paquete", in_sig=None, out_sig=None
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.construir)

          def construir(self, mensaje):
              if not pmt.is_pdu(mensaje) or not pmt.is_u8vector(pmt.cdr(mensaje)):
                  print("Construir paquete: se esperaba una PDU de bytes.")
                  return

              datos = bytes(pmt.u8vector_elements(pmt.cdr(mensaje)))
              if len(datos) > 5000:
                  print("Construir paquete: el texto supera 5000 bytes. No se envía.")
                  return

              try:
                  texto = datos.decode("utf-8")
              except UnicodeDecodeError:
                  print("Construir paquete: los bytes no forman un texto UTF-8 válido.")
                  return

              palabras = texto.split()
              if not palabras:
                  print("Construir paquete: mensaje vacío. No se envía.")
                  return
              if len(palabras) > 500:
                  print("Construir paquete: el texto supera 500 palabras. No se envía.")
                  return

              # La longitud cuenta solo los bytes originales del texto.
              cabecera = struct.pack("!H", len(datos))
              contenido = cabecera + datos
              crc = struct.pack("!I", zlib.crc32(contenido))
              paquete = contenido + crc

              # Los metadatos siguen separados de los bytes del paquete.
              vector = pmt.init_u8vector(len(paquete), list(paquete))
              salida = pmt.cons(pmt.car(mensaje), vector)
              self.message_port_pub(pmt.intern("out"), salida)
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import struct
      import zlib


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self, name="Comprobar paquete", in_sig=None, out_sig=None
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.comprobar)

          def comprobar(self, mensaje):
              if not pmt.is_pdu(mensaje) or not pmt.is_u8vector(pmt.cdr(mensaje)):
                  print("Comprobar paquete: se esperaba una PDU de bytes.")
                  return

              paquete = bytes(pmt.u8vector_elements(pmt.cdr(mensaje)))

              # Primero debe haber espacio para longitud y CRC.
              if len(paquete) < 6:
                  print("Comprobar paquete: paquete demasiado corto. Se rechaza.")
                  return

              longitud = struct.unpack("!H", paquete[:2])[0]
              if not 1 <= longitud <= 5000:
                  print("Comprobar paquete: longitud no permitida. Se rechaza.")
                  return

              if len(paquete) != longitud + 6:
                  print("Comprobar paquete: el tamaño no coincide. Se rechaza.")
                  return

              crc_recibido = struct.unpack("!I", paquete[-4:])[0]
              crc_calculado = zlib.crc32(paquete[:-4])
              if crc_recibido != crc_calculado:
                  print("Comprobar paquete: CRC incorrecto. Se rechaza.")
                  return

              # Solo se entregan los bytes del texto, sin longitud ni CRC.
              datos = paquete[2:-4]
              vector = pmt.init_u8vector(len(datos), list(datos))
              salida = pmt.cons(pmt.car(mensaje), vector)
              self.message_port_pub(pmt.intern("out"), salida)
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self, name="Alterar segundo paquete", in_sig=None, out_sig=None
              )

              self.contador = 0
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.procesar)

          def procesar(self, mensaje):
              if not pmt.is_pdu(mensaje) or not pmt.is_u8vector(pmt.cdr(mensaje)):
                  print("Inyector: se esperaba una PDU de bytes.", flush=True)
                  return

              paquete = bytearray(pmt.u8vector_elements(pmt.cdr(mensaje)))
              if len(paquete) < 7:
                  print("Inyector: paquete demasiado corto.", flush=True)
                  return

              self.contador += 1
              if self.contador == 2:
                  # Índices 0 y 1: longitud. Índice 2: primer byte del texto.
                  paquete[2] ^= 0x01
                  print("Inyector: paquete 2, bit alterado.", flush=True)
              else:
                  print(f"Inyector: paquete {self.contador}, sin cambios.", flush=True)

              # Se conserva el CRC recibido; no se calcula otro CRC.
              vector = pmt.init_u8vector(len(paquete), list(paquete))
              salida = pmt.cons(pmt.car(mensaje), vector)
              self.message_port_pub(pmt.intern("out"), salida)
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self, name="Bytes a bits", in_sig=None, out_sig=None
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.convertir)

          def convertir(self, mensaje):
              if not pmt.is_pdu(mensaje) or not pmt.is_u8vector(pmt.cdr(mensaje)):
                  print("Bytes a bits: se esperaba una PDU de bytes.", flush=True)
                  return

              datos = pmt.u8vector_elements(pmt.cdr(mensaje))
              if not datos:
                  print("Bytes a bits: vector vacío.", flush=True)
                  return

              bits = []
              for byte in datos:
                  for posicion in range(7, -1, -1):
                      bits.append((byte >> posicion) & 1)

              vector = pmt.init_u8vector(len(bits), bits)
              salida = pmt.cons(pmt.car(mensaje), vector)
              self.message_port_pub(pmt.intern("out"), salida)
  states: {}
- name: extraer_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: filtro_rx
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_alpha
    decim: '1'
    gain: '1'
    interp: sps
    ntaps: rrc_ntaps
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: frecuencia_a_hz
  id: blocks_multiply_const_vxx
  parameters:
    const: symbol_rate/(2*np.pi)
    type: float
  states: {}
- name: frecuencia_estimada
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: vistas@2:0,0,1,2
    label1: '"Estimacion RX"'
    name: '"Frecuencia estimada por Costas"'
    size: '192'
    srate: symbol_rate
    type: float
    update_time: '0.01'
    ylabel: '"Frecuencia estimada"'
    ymax: '25'
    ymin: '-25'
    yunit: '"Hz"'
  states: {}
- name: invertir_bits
  id: digital_map_bb
  parameters:
    map: '[1, 0]'
  states: {}
- name: longitud_muestras
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: longitud_rrc
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: mapeador
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j,1+0j]'
  states: {}
- name: muestras_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: muestrear_rx
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: x[retardo_total:-cierre_rx_muestras:sps]'
    metadict: Uniform Vector
  states: {state: disabled}
- name: muestrear_stream
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: sps
    offset: offset_muestreo
    type: complex
  states: {state: disabled}
- name: paquete_rx_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_invertida
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pulso_rect
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: pulso_rrc
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_alpha
    gain: sps
    interp: sps
    ntaps: rrc_ntaps
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: interp_fir_filter_ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: vistas@0:1,0,1,2
    name: '"Simbolos BPSK"'
    type: msg_complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,2
    is_pair: 'False'
    label: Mensaje de A
    type: string
  states: {}
- name: recuperar_fase
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_bw
  states: {}
- name: reloj_estimado
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: vistas@3:0,0,1,2
    label1: '"T_avg RX"'
    name: '"Periodo estimado por Symbol Sync"'
    size: '128'
    srate: symbol_rate
    type: float
    update_time: '0.01'
    ylabel: '"Periodo estimado"'
    ymax: '4.06'
    ymin: '3.94'
    yunit: '"muestras/simbolo"'
  states: {}
- name: resumen_ensayo
  id: snippet
  parameters:
    code: |-
      n_tx = self.debug_trama_tx.num_messages()
      n_normal = len(self.debug_deteccion.current_tags())
      n_invertida = len(self.debug_invertida.current_tags())
      n_det = n_normal + n_invertida
      n_rx = self.debug_paquete_rx.num_messages()
      n_ok = self.blocks_message_debug_0.num_messages()
      print(f"RESUMEN amplitud={self.ruido_amplitud} semilla={self.ruido_semilla}", flush=True)
      print(f"TX={n_tx} DET={n_det} RX={n_rx} OK={n_ok}", flush=True)
      print(f"RECH={n_rx-n_ok} SIN_PDU={n_tx-n_rx} SIN_TEXTO={n_tx-n_ok}", flush=True)
      print("TEXTOS_OK=", [pmt.symbol_to_string(self.blocks_message_debug_0.get_message(i)) for i in range(n_ok)], flush=True)
      print(f"FASE grados={self.fase_grados} costas={'activo' if hasattr(self, 'recuperar_fase') else 'sin_lazo'}", flush=True)
      print(f"POLARIDAD normal={n_normal} invertida={n_invertida}", flush=True)
      print(f"FRECUENCIA offset_hz={self.frecuencia_offset_hz}", flush=True)
      print(f"TIEMPO retardo_muestras={self.retardo_muestras} offset_muestreo={self.offset_muestreo}", flush=True)
      print(f"RELOJ ppm={self.reloj_ppm} temporal={'activo' if hasattr(self, 'sincronizar_simbolos') else 'fijo'}", flush=True)
    section: main_after_stop
  states: {}
- name: retardar_canal
  id: blocks_delay
  parameters:
    delay: retardo_muestras
    type: complex
  states: {state: disabled}
- name: rotar_fase
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*np.deg2rad(fase_grados))
    type: complex
  states: {}
- name: rrc_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: ruido
  id: analog_noise_source_x
  parameters:
    amp: ruido_amplitud
    noise_type: analog.GR_GAUSSIAN
    seed: ruido_semilla
    type: complex
  states: {}
- name: rx_a_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: rx_a_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: sin_etiquetas
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: sincronizar_simbolos
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.08'
    max_dev: '0.05'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.a_stream.set_min_output_buffer(0, self.max_trama_bits * 2)
      self.mapeador.set_min_output_buffer(0, self.max_trama_bits * 2)
      self.pulso_rect.set_min_output_buffer(0, self.max_trama_bits * self.sps * 2)
      self.longitud_muestras.set_min_output_buffer(0, self.max_trama_bits * self.sps * 2)
      self.cierre_rrc.set_min_output_buffer(0, (self.max_trama_bits + self.rrc_span) * 2)
      self.pulso_rrc.set_min_output_buffer(0, (self.max_trama_bits + self.rrc_span) * self.sps * 2)
      self.longitud_rrc.set_min_output_buffer(0, (self.max_trama_bits + self.rrc_span) * self.sps * 2)
      self.cierre_rx.set_min_output_buffer(0, ((self.max_trama_bits + self.rrc_span) * self.sps + self.cierre_rx_muestras) * 2)
      self.filtro_rx.set_min_output_buffer(0, ((self.max_trama_bits + self.rrc_span) * self.sps + self.cierre_rx_muestras) * 2)
      self.decidir_bits.set_min_output_buffer(0, self.max_trama_bits * 2)
      self.detectar_trama.set_min_output_buffer(0, (5000 + 6) * 8 * 2)
      self.debug_deteccion.set_save_all(True)
      self.detectar_invertida.set_min_output_buffer(0, (5000 + 6) * 8 * 2)
      self.debug_invertida.set_save_all(True)
    section: main_after_init
  states: {}
- name: sumar_ruido
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: tiempo_bpsk
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: vistas@0:0,0,1,1
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    name: '"Senal temporal BPSK"'
    srate: samp_rate
    type: msg_complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: tiempo_rrc
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: vistas@0:0,1,1,1
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    name: '"Senal temporal BPSK RRC"'
    srate: samp_rate
    type: msg_complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tiempo_rx
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: vistas@1:0,0,1,2
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    name: '"Senal RX: ventana de 64 ms"'
    size: '256'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: vistas
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Transmisor
    label1: Receptor ideal
    label2: Sincronizacion
    label3: Temporizacion
    num_tabs: '4'
  states: {}

connections:
- [a_stream, '0', mapeador, '0']
- [cierre_rrc, '0', pulso_rrc, '0']
- [cierre_rx, '0', sin_etiquetas, '0']
- [decidir_bits, '0', detectar_trama, '0']
- [decidir_bits, '0', invertir_bits, '0']
- [desajustar_frecuencia, '0', desajustar_reloj, '0']
- [desajustar_frecuencia, '0', retardar_canal, '0']
- [desajustar_reloj, '0', sumar_ruido, '0']
- [detectar_invertida, '0', debug_invertida, '0']
- [detectar_invertida, '0', empaquetar_invertida, '0']
- [detectar_trama, '0', debug_deteccion, '0']
- [detectar_trama, '0', empaquetar_bits, '0']
- [empaquetar_bits, '0', paquete_rx_a_pdu, '0']
- [empaquetar_invertida, '0', pdu_invertida, '0']
- [envolver_trama, pdu, debug_trama_tx, print]
- [envolver_trama, pdu, debug_trama_tx, store]
- [envolver_trama, pdu, epy_block_5, in]
- [epy_block_0, out, epy_block_2, in]
- [epy_block_1, out, blocks_message_debug_0, print]
- [epy_block_1, out, blocks_message_debug_0, store]
- [epy_block_2, out, envolver_trama, pdu]
- [epy_block_3, out, epy_block_1, in]
- [epy_block_5, out, a_stream, pdus]
- [extraer_i, '0', decidir_bits, '0']
- [filtro_rx, '0', muestrear_stream, '0']
- [filtro_rx, '0', rx_a_pdu, '0']
- [filtro_rx, '0', sincronizar_simbolos, '0']
- [filtro_rx, '0', tiempo_rx, '0']
- [frecuencia_a_hz, '0', frecuencia_estimada, '0']
- [invertir_bits, '0', detectar_invertida, '0']
- [longitud_muestras, '0', muestras_a_pdu, '0']
- [longitud_rrc, '0', cierre_rx, '0']
- [longitud_rrc, '0', rrc_a_pdu, '0']
- [mapeador, '0', cierre_rrc, '0']
- [mapeador, '0', pdu_tagged_stream_to_pdu_0, '0']
- [mapeador, '0', pulso_rect, '0']
- [muestras_a_pdu, pdus, debug_muestras, print]
- [muestras_a_pdu, pdus, tiempo_bpsk, in]
- [muestrear_rx, pdu, constelacion_rx, '0']
- [muestrear_rx, pdu, debug_simbolos_rx, print]
- [muestrear_rx, pdu, rx_a_stream, pdus]
- [muestrear_stream, '0', constelacion_rx, '0']
- [muestrear_stream, '0', recuperar_fase, '0']
- [paquete_rx_a_pdu, pdus, debug_paquete_rx, print]
- [paquete_rx_a_pdu, pdus, debug_paquete_rx, store]
- [paquete_rx_a_pdu, pdus, epy_block_3, in]
- [pdu_invertida, pdus, debug_paquete_rx, print]
- [pdu_invertida, pdus, debug_paquete_rx, store]
- [pdu_invertida, pdus, epy_block_3, in]
- [pdu_tagged_stream_to_pdu_0, pdus, qtgui_const_sink_x_0, in]
- [pulso_rect, '0', longitud_muestras, '0']
- [pulso_rrc, '0', longitud_rrc, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0, in]
- [recuperar_fase, '0', constelacion_fase, '0']
- [recuperar_fase, '0', extraer_i, '0']
- [recuperar_fase, '1', frecuencia_a_hz, '0']
- [retardar_canal, '0', sumar_ruido, '0']
- [rotar_fase, '0', desajustar_frecuencia, '0']
- [rrc_a_pdu, pdus, debug_rrc, print]
- [rrc_a_pdu, pdus, tiempo_rrc, in]
- [ruido, '0', sumar_ruido, '1']
- [rx_a_pdu, pdus, debug_rx, print]
- [rx_a_pdu, pdus, muestrear_rx, pdu]
- [rx_a_pdu, pdus, tiempo_rx, '0']
- [rx_a_stream, '0', extraer_i, '0']
- [sin_etiquetas, '0', debug_sin_etiquetas, '0']
- [sin_etiquetas, '0', rotar_fase, '0']
- [sincronizar_simbolos, '0', constelacion_rx, '0']
- [sincronizar_simbolos, '0', recuperar_fase, '0']
- [sincronizar_simbolos, '1', descartar_ted, '0']
- [sincronizar_simbolos, '2', descartar_ted, '1']
- [sincronizar_simbolos, '3', reloj_estimado, '0']
- [sumar_ruido, '0', filtro_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
