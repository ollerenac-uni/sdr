options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: eye_diagram_fg
    output_language: python
    title: Eye Diagram Flowgraph
  states: {}

blocks:
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    label: Excess BW
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: nEyes
  id: variable
  parameters:
    value: '2'
  states: {}
- name: offs
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 0*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 1*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 2*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 7*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 6*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 4*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 5*samp_per_sym+offs
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 20*samp_per_sym
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    color4: red
    grid: 'True'
    label1: Trace 0
    label2: Trace 1
    label3: Trace 2
    label4: Trace 3
    label5: Trace 4
    label6: Trace 5
    label7: Trace 6
    label8: Trace 7
    name: Eye Diagram
    nconnections: '8'
    size: nEyes*samp_per_sym
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: qtx_pam_0
  id: qtx_pam
  parameters:
    comment: Custom PAM Block
    excess_BW: excess_bw
    sampleRate: samp_rate
    samplesPerSymbol: samp_per_sym
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_fff
  states: {}

connections:
- [analog_random_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0, '7']
- [blocks_delay_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_delay_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_skiphead_0, '0', blocks_delay_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', qtx_pam_0, '0']
- [qtx_pam_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
