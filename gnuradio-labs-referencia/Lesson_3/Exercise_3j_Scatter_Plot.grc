options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: scatter_plot
    output_language: python
    title: Scatter Plot
  states: {}

blocks:
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    label: Excess BW
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.9'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    legend: 'False'
    name: Scatter Plot
    size: '1024'
    type: complex
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: samp_per_sym
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [qtx_qam_waveform_baseband_0, '0', root_raised_cosine_filter_1, '0']
- [root_raised_cosine_filter_1, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
