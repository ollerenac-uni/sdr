options:
  parameters:
    author: Qasim Chaudhari
    category: '[qBlocks]'
    generate_options: hb
    id: qtx_pam
    output_language: python
    title: PAM Waveform
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table
    map: (-1,1)
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    label: Excess BW
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Upsampler
    interp: samp_per_sym
    taps: np.hstack((1,np.zeros(samp_per_sym-1)))
    type: fff
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Bits
    type: byte
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Pulse Shaping Filter
    gain: samp_per_sym
    interp: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_fff
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples/Symbol
    value: '4'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '8000'
  states: {}

connections:
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [pad_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
