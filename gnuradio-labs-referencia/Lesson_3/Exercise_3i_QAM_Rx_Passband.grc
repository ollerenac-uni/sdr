options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: qam_rx_passband
    output_language: python
    title: QAM Rx Passband
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: downsample_delay
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: math.sqrt(2)
    comment: Local Oscillator Cosine
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-math.sqrt(2)'
    comment: Local Oscillator Sine
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: downsample_delay
    type: float
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: downsample_delay
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,0,1,0)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Downsampler I
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Downsampler Q
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,2,1,1
    legend: 'False'
    name: Scatter Plot
    size: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    name: Downsampled I Arm
    size: '10'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,2,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    name: Downsampled Q Arm
    size: '10'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: ''
    legend: 'False'
    name: Downconverted Q Arm
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: ''
    legend: 'False'
    name: Matched Filtered Q Waveform
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: ''
    legend: 'False'
    name: Downconverted I Arm
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: I
    legend: 'False'
    name: Rx Waveform
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: ''
    legend: 'False'
    name: Matched Filtered I Waveform
    size: '200'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtx_qam_waveform_passband_0
  id: qtx_qam_waveform_passband
  parameters:
    carrier_Freq: carrier_freq
    comment: Custom QAM Block
    excess_BW: excess_bw
    sampleRate: samp_rate
    samplesPerSymbol: samp_per_sym
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter I
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched Filter Q
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_complex_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_passband_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [qtx_qam_waveform_passband_0, '0', blocks_multiply_xx_0, '1']
- [qtx_qam_waveform_passband_0, '0', blocks_multiply_xx_0_0, '0']
- [qtx_qam_waveform_passband_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_skiphead_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_2, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_skiphead_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
