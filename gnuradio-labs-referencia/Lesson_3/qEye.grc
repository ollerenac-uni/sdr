options:
  parameters:
    author: Qasim Chaudhari
    category: '[qBlocks]'
    generate_options: hb_qt_gui
    id: qEye
    output_language: python
    title: Eye Diagram
  states: {}

blocks:
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 0*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 1*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 2*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 7*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 6*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 4*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 5*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: 10*samp_per_sym
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: 9*samp_per_sym
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(20*samp_per_sym+samp_per_sym/2)
    type: float
  states: {}
- name: eye_string
  id: parameter
  parameters:
    label: Eye Label
    type: str
    value: '''Eye Diagram'''
  states: {}
- name: nEyes
  id: parameter
  parameters:
    label: Number of Eyes
    type: intx
    value: '2'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color4: red
    grid: 'True'
    label1: Trace 0
    label2: Trace 1
    label3: Trace 2
    label4: Trace 3
    label5: Trace 4
    label6: Trace 5
    label7: Trace 6
    label8: Trace 7
    legend: 'False'
    name: eye_string
    nconnections: '10'
    size: nEyes*samp_per_sym
    srate: samp_rate
    type: float
    ymax: ymax
    ymin: ymin
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '32'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '8000'
  states: {}
- name: ymax
  id: parameter
  parameters:
    label: Y Max
    type: eng_float
    value: '1'
  states: {}
- name: ymin
  id: parameter
  parameters:
    label: Y Min
    type: eng_float
    value: '-1'
  states: {}

connections:
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0, '7']
- [blocks_delay_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_delay_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0_0_1, '0', qtgui_time_sink_x_0, '9']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '8']
- [blocks_skiphead_0, '0', blocks_delay_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_0_0_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0_1, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_1, '0']
- [pad_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
