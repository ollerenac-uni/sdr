options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: squaring_pam
    output_language: python
    title: Squaring a PAM Signal
  states: {}

blocks:
- name: excess_bw
  id: variable_qtgui_chooser
  parameters:
    label: Excess Bandwidth
    label0: '0.1'
    label1: '0.5'
    label2: '1'
    num_opts: '3'
    option1: '0.5'
    option2: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '0.1'
    widget: radio_buttons
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 1,1,1,1
    legend: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: ''
    legend: 'False'
    name: Product
    size: 15*samp_per_sym
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '4'
  states: {}
- name: qtx_pam_0
  id: qtx_pam
  parameters:
    excess_BW: excess_bw
    sampleRate: samp_rate
    samplesPerSymbol: samp_per_sym
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtx_pam_0, '0']
- [qtx_pam_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
