options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: multipath_channel_doppler_data
    output_language: python
    title: Multipath Channel Doppler Data
  states: {}

blocks:
- name: amp_path_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Amp Path 0
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: amp_path_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Amp Path 1
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: delay_path_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay Path 0
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: delay_path_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Delay Path 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: disp_points
  id: variable
  parameters:
    value: '100'
  states: {}
- name: doppler_path_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Doppler Path 0
    orient: Qt.Horizontal
    start: '-max_doppler'
    step: '1'
    stop: max_doppler
    value: '0'
  states: {}
- name: doppler_path_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Doppler Path 1
    orient: Qt.Horizontal
    start: '-max_doppler'
    step: '1'
    stop: max_doppler
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: max_doppler
  id: variable
  parameters:
    value: carrier_freq/10
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Rx Antenna
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_path_0
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_path_1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_path_0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_path_1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./float(math.sqrt(amp_path_0**2+amp_path_1**2**2))
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/4
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 5,1,1,1
    label1: At Ant
    name: Rx Spectrum
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,1,1,1
    label1: Path 0
    label2: Path 1
    name: Tx Spectrum
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: Path 0
    label2: Path 1
    name: Arriving Multipath
    nconnections: '2'
    size: disp_points
    srate: samp_rate
    style2: '2'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: At Ant
    name: Rx Signal
    size: disp_points
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    comment: Custom QAM Block
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}
- name: qupconverter_0
  id: qupconverter
  parameters:
    carrier_freq: carrier_freq+doppler_path_0
    comment: Doppler Path 0
    samp_rate: samp_rate
  states: {}
- name: qupconverter_0_0
  id: qupconverter
  parameters:
    carrier_freq: carrier_freq+doppler_path_1
    comment: Doppler Path 1
    samp_rate: samp_rate
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_1, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [qtx_qam_waveform_baseband_0, '0', qupconverter_0, '0']
- [qtx_qam_waveform_baseband_0, '0', qupconverter_0_0, '0']
- [qupconverter_0, '0', blocks_delay_0, '0']
- [qupconverter_0_0, '0', blocks_delay_0_0, '0']

metadata:
  file_format: 1
