options:
  parameters:
    author: Qasim Chaudhari
    generate_options: qt_gui
    id: fll_band_edge
    output_language: python
    title: FLL Band Edge
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: '1000'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Loop Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier Frequency Offset
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '64'
    rolloff: excess_bw
    samps_per_sym: samp_per_sym
    type: cc
    w: loop_bw
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np; import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@1: [0,0,1,1]'
    legend: 'False'
    name: Rx Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@1: [0,1,1,1]'
    legend: 'False'
    name: Recovered Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-60'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@0: [0,0,1,1]'
    label1: I
    label2: Q
    name: Rx Signal
    size: 10*samp_per_sym
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@0: [0,1,1,1]'
    label1: I
    label2: Q
    name: FLL Out
    size: 10*samp_per_sym
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: green
    color3: red
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Frequency
    label2: Phase
    label3: Error
    name: Error Signal
    nconnections: '3'
    size: 10*samp_per_sym
    srate: samp_rate
    type: float
  states: {}
- name: qtx_qam_waveform_baseband_0
  id: qtx_qam_waveform_baseband
  parameters:
    excess_bw: excess_bw
    samp_per_sym: samp_per_sym
    samp_rate: samp_rate
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtx_qam_waveform_baseband_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [digital_fll_band_edge_cc_0, '2', qtgui_time_sink_x_0_0_0, '1']
- [digital_fll_band_edge_cc_0, '3', qtgui_time_sink_x_0_0_0, '2']
- [qtx_qam_waveform_baseband_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
