options:
  parameters:
    author: ollerenac-uni
    description: Compara un moving average y un low-pass con dos tonos I/Q, sin hardware.
    generate_options: qt_gui
    id: filtros_sesion03
    output_language: python
    title: 'Laboratorio #3 - Filtros FIR'
  states: {}

blocks:
- name: import_scipy
  id: import
  parameters:
    imports: from scipy import signal as dsp_signal
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: modo_filtro
  id: variable
  parameters:
    comment: '0: moving average de tres taps. 1: low-pass preparado de 65 taps. Detener, cambiar y ejecutar.'
    value: '0'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1/3, 1/3, 1/3] if modo_filtro == 0 else dsp_signal.firwin(65, 3000, fs=samp_rate).tolist()'
  states: {}
- name: tono_util
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tono_no_deseado
  id: analog_sig_source_x
  parameters:
    amp: '0.6'
    freq: '9000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: suma_tonos
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: ritmo
  id: blocks_throttle2
  parameters:
    comment: Pacing de un stream complejo generado en software; no modifica sus valores ni su sampling rate.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir
  id: fir_filter_xxx
  parameters:
    comment: Entradas y salidas complejas, taps reales, sin decimación.
    decim: '1'
    taps: taps
    type: ccf
  states: {}
- name: espectros
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label: Nivel relativo
    label1: Entrada
    label2: Salida
    name: '"Entrada y salida del FIR"'
    nconnections: '2'
    type: complex
    width1: '2'
    width2: '2'
    ymin: '-100'
  states: {}

connections:
- [tono_util, '0', suma_tonos, '0']
- [tono_no_deseado, '0', suma_tonos, '1']
- [suma_tonos, '0', ritmo, '0']
- [ritmo, '0', fir, '0']
- [ritmo, '0', espectros, '0']
- [fir, '0', espectros, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
