options:
  parameters:
    description: Captura de 2.048 Msps. Contiene una inconsistencia de tasa en la rama RDS para la parte 3 del laboratorio.
    generate_options: qt_gui
    id: fm_lab04_diagnostico
    output_language: python
    title: Laboratorio 4 — Diagnóstico FM/RDS
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: decimacion_audio
  id: variable
  parameters:
    value: '4'
  states: {}
- name: decimacion_fir
  id: variable
  parameters:
    value: '8'
  states: {}
- name: desplazamiento_sintonia
  id: variable
  parameters:
    comment: Hz. Cero sintoniza directamente; 250e3 permite separar el centro de captura.
    value: '0'
  states: {}
- name: desviacion_fm
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: frecuencia_central
  id: variable
  parameters:
    value: 89.4e6
  states: {}
- name: frecuencia_emisora
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la emisora (MHz)
    start: '87.0'
    step: '0.1'
    stop: '108.0'
    value: '88.9'
  states: {}
- name: frecuencia_emisora_hz
  id: variable
  parameters:
    comment: Frecuencia RF en Hz; el control utiliza MHz.
    value: frecuencia_emisora * M
  states: {}
- name: frecuencia_mezcla
  id: variable
  parameters:
    value: frecuencia_central - frecuencia_emisora_hz
  states: {}
- name: ganancia_rf
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF (dB)
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '29.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: tasa_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tasa_audio_intermedia
  id: variable
  parameters:
    value: tasa_canal / decimacion_audio
  states: {}
- name: tasa_canal
  id: variable
  parameters:
    value: samp_rate/decimacion_fir
  states: {}
- name: tasa_rds
  id: variable
  parameters:
    value: tasa_canal / 16
  states: {}
- name: audio_48k
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.4'
    interp: '3'
    type: fff
  states: {}
- name: audio_mono
  id: audio_sink
  parameters:
    samp_rate: tasa_audio
  states: {}
- name: bifase_rds
  id: satellites_manchester_sync
  parameters:
    block_size: '32'
    type: complex
  states: {}
- name: campos_rds
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: centrar_emisora
  id: cbs33m_rotador_frecuencia
  parameters:
    frecuencia_mezcla: frecuencia_mezcla
    samp_rate: samp_rate
  states: {}
- name: centrar_rds
  id: cbs33m_rotador_frecuencia
  parameters:
    frecuencia_mezcla: '-57000'
    samp_rate: '300000'
  states: {}
- name: componente_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: conversor_iq
  id: cbs33m_cu8_a_c64
  parameters:
    escala: '127.5'
  states: {}
- name: decision_rds
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: decodificador_rds
  id: rds_decoder
  parameters: {}
  states: {}
- name: deenfasis
  id: analog_fm_deemph
  parameters:
    samp_rate: tasa_audio
    tau: '75e-6'
  states: {}
- name: demodulador_fm
  id: analog_quadrature_demod_cf
  parameters:
    gain: tasa_canal / (2 * math.pi * desviacion_fm)
  states: {}
- name: diferencial_rds
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: fase_rds
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: filtro_audio
  id: fir_filter_xxx
  parameters:
    decim: decimacion_audio
    taps: firdes.low_pass(1.0, tasa_canal, 16e3, 2e3)
    type: fff
  states: {}
- name: filtro_canal
  id: fir_filter_xxx
  parameters:
    decim: decimacion_fir
    taps: firdes.low_pass(1.0, samp_rate, 100e3, 20e3)
    type: ccf
  states: {}
- name: filtro_rds
  id: fir_filter_xxx
  parameters:
    decim: '16'
    taps: firdes.low_pass(1.0, tasa_canal, 3e3, 1e3)
    type: ccf
  states: {}
- name: fuente_captura
  id: blocks_file_source
  parameters:
    file: ../samples/fm-lima-20261107/fm_lima_fc89p4MHz_2p048Msps_g20p7_30s.cu8
    repeat: 'False'
    type: byte
  states: {}
- name: ganancia_rds
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: complex
  states: {}
- name: grupos_rds
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: multiplex_complejo
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: normalizar_rds
  id: analog_agc_xx
  parameters:
    comment: Normalizar la amplitud antes de Costas.
    gain: '1.0'
    max_gain: '100'
    rate: '2e-3'
    reference: '0.7'
    type: complex
  states: {}
- name: panel_rds
  id: rds_panel
  parameters:
    comment: La biblioteca espera Hz al construir y MHz al actualizar. La etiqueta inicial puede mostrar 0.0; cambiar la sintonía actualiza la etiqueta. No afecta a la recepción RF.
    freq: frecuencia_emisora
  states: {}
- name: parser_rds
  id: rds_parser
  parameters:
    pty_locale: '0'
    reset: frecuencia_emisora
  states: {}
- name: pulsos_rds
  id: root_raised_cosine_filter
  parameters:
    alpha: '1.0'
    decim: '1'
    gain: '1'
    ntaps: '101'
    samp_rate: tasa_rds
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After Costas Loop"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After RRC  Filter"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After Symbol Sync"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tasa_canal
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: tasa_canal
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: tasa_audio_intermedia
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: tasa_rds
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: reloj_rds
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: tasa_rds/2375
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: ritmo_visores
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '40'
    freq0: frecuencia_central
    gain0: ganancia_rf
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: volumen
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}

connections:
- [audio_48k, '0', deenfasis, '0']
- [bifase_rds, '0', componente_i, '0']
- [centrar_emisora, '0', filtro_canal, '0']
- [centrar_emisora, '0', qtgui_freq_sink_x_0, '1']
- [centrar_rds, '0', filtro_rds, '0']
- [componente_i, '0', decision_rds, '0']
- [conversor_iq, '0', ritmo_visores, '0']
- [decision_rds, '0', diferencial_rds, '0']
- [decodificador_rds, out, grupos_rds, print]
- [decodificador_rds, out, parser_rds, in]
- [deenfasis, '0', volumen, '0']
- [demodulador_fm, '0', filtro_audio, '0']
- [demodulador_fm, '0', multiplex_complejo, '0']
- [demodulador_fm, '0', qtgui_freq_sink_x_0_0_0, '0']
- [diferencial_rds, '0', decodificador_rds, '0']
- [fase_rds, '0', pulsos_rds, '0']
- [fase_rds, '0', qtgui_const_sink_x_0, '0']
- [filtro_audio, '0', audio_48k, '0']
- [filtro_audio, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [filtro_canal, '0', demodulador_fm, '0']
- [filtro_canal, '0', qtgui_freq_sink_x_0_0, '0']
- [filtro_rds, '0', ganancia_rds, '0']
- [filtro_rds, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [fuente_captura, '0', conversor_iq, '0']
- [ganancia_rds, '0', normalizar_rds, '0']
- [multiplex_complejo, '0', centrar_rds, '0']
- [normalizar_rds, '0', fase_rds, '0']
- [parser_rds, out, campos_rds, store]
- [parser_rds, out, panel_rds, in]
- [pulsos_rds, '0', qtgui_const_sink_x_0_0, '0']
- [pulsos_rds, '0', reloj_rds, '0']
- [reloj_rds, '0', bifase_rds, '0']
- [reloj_rds, '0', qtgui_const_sink_x_0_0_0, '0']
- [ritmo_visores, '0', centrar_emisora, '0']
- [ritmo_visores, '0', qtgui_freq_sink_x_0, '0']
- [ritmo_visores, '0', qtgui_time_sink_x_0, '0']
- [ritmo_visores, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', centrar_emisora, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [volumen, '0', audio_mono, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
