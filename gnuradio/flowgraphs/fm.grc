options:
  parameters:
    generate_options: qt_gui
    id: fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 1.0e6
  states: {}
- name: decimacion_fir
  id: variable
  parameters:
    value: '8'
  states: {}
- name: desviacion_fm
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq_sint
  id: variable_qtgui_range
  parameters:
    start: '97.9'
    step: '0.1'
    stop: '100.3'
    value: '98.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4*M
  states: {}
- name: tasa_canal
  id: variable
  parameters:
    value: samp_rate/decimacion_fir
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: tasa_canal / (2 * math.pi * desviacion_fm)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../samples/fm_99p1MHz_2p4Msps_g30.cu8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: 12000/2375
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Convierte bytes I/Q intercalados a muestras complejas"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='Conversor de .cu8 a .c64',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.complex64],
                  decim=2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              # self.example_param = example_param

          def work(self, input_items, output_items):
              # espacio dispnible para muestras complejas
              n = len(output_items[0])

              # dos bytes de entrada por cada complejo de salida
              datos = input_items[0][:n*2]

              # se separan los bytes I y Q
              i = datos[::2].astype(np.float32)
              q = datos[1::2].astype(np.float32)

              # centrar y normalizar cada componente
              i = i / 127.5 - 1.0
              q = q / 127.5 - 1.0

              # construir la muestra compleja
              output_items[0][:] = i + 1j * q
              return n
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Desplaza el espectro mediante una exponencial compleja."""

          def __init__(self, frecuencia_mezcla=0.0, samp_rate=2.4e6):
              gr.sync_block.__init__(
                  self,
                  name='Rotador de frecuencia',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.frecuencia_mezcla = float(frecuencia_mezcla)
              self.samp_rate = float(samp_rate)

              # Fase que corresponde a la próxima muestra.
              self.fase = 0.0

          def work(self, input_items, output_items):
              n = len(output_items[0])

              # Radianes que avanza el oscilador por muestra.
              incremento = (
                  2 * np.pi * self.frecuencia_mezcla / self.samp_rate
              )

              # Fases de las n muestras de este lote.
              indices = np.arange(n, dtype=np.float64)
              fases = self.fase + incremento * indices

              # Exponencial compleja y multiplicación de las muestras.
              oscilador = np.exp(1j * fases)
              output_items[0][:n] = input_items[0][:n] * oscilador

              # Conservar la fase de la siguiente muestra.
              self.fase = (self.fase + incremento * n) % (2 * np.pi)

              return n
    frecuencia_mezcla: 99.1*1e6 - freq_sint*M
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Desplaza el espectro mediante una exponencial compleja."""

          def __init__(self, frecuencia_mezcla=0.0, samp_rate=2.4e6):
              gr.sync_block.__init__(
                  self,
                  name='Rotador de frecuencia',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.frecuencia_mezcla = float(frecuencia_mezcla)
              self.samp_rate = float(samp_rate)

              # Fase que corresponde a la próxima muestra.
              self.fase = 0.0

          def work(self, input_items, output_items):
              n = len(output_items[0])

              # Radianes que avanza el oscilador por muestra.
              incremento = (
                  2 * np.pi * self.frecuencia_mezcla / self.samp_rate
              )

              # Fases de las n muestras de este lote.
              indices = np.arange(n, dtype=np.float64)
              fases = self.fase + incremento * indices

              # Exponencial compleja y multiplicación de las muestras.
              oscilador = np.exp(1j * fases)
              output_items[0][:n] = input_items[0][:n] * oscilador

              # Conservar la fase de la siguiente muestra.
              self.fase = (self.fase + incremento * n) % (2 * np.pi)

              return n
    frecuencia_mezcla: '-57000'
    samp_rate: tasa_canal
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimacion_fir
    taps: firdes.low_pass(1.0, samp_rate, 120e3, 30e3)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '6'
    taps: firdes.low_pass(1.0, tasa_canal, 16e3, 2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '25'
    taps: firdes.low_pass(1.0, tasa_canal, 3e3, 1e3)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After Costas Loop"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After RRC  Filter"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After Symbol Sync"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/8
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: tasa_canal
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: tasa_canal/6
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: tasa_canal/25
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '24'
    type: fff
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters:
    log: 'True'
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    log: 'True'
    pty_locale: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1.0'
    decim: '1'
    gain: '1'
    ntaps: '101'
    samp_rate: '12000'
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}
- name: satellites_manchester_sync_0
  id: satellites_manchester_sync
  parameters:
    block_size: '32'
    type: complex
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_manchester_sync_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_1, '0', fir_filter_xxx_0, '0']
- [epy_block_1, '0', qtgui_freq_sink_x_0, '1']
- [epy_block_1_0, '0', fir_filter_xxx_0_1, '0']
- [fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [fir_filter_xxx_0_0, '0', rational_resampler_xxx_0, '0']
- [fir_filter_xxx_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [fir_filter_xxx_0_1, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, blocks_message_debug_0, print]
- [rds_parser_0, out, rds_panel_0, in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0_0, '0']
- [satellites_manchester_sync_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
