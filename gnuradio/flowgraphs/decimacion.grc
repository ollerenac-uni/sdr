options:
  parameters:
    description: Compara descarte directo y decimación con prefiltro sobre la muestra oficial.
    generate_options: qt_gui
    id: decimacion
    output_language: python
    title: Laboratorio de muestreo - Decimación con y sin filtro
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    comment: Factor de decimación.
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Centra el cero CU8 en 127.5.
    const: '-127.5'
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Muestra CU8 oficial: I, Q, I, Q.'
    file: ../samples/fm_99p1MHz_2p4Msps_g30.cu8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Descarta siete de cada ocho muestras sin filtrar.
    n: D
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Escala aproximadamente a -1..1.
    const: 1/127.5
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Dos bytes por muestra compleja.
    samples_per_second: 2*samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Filtra antes de conservar una de cada D muestras.
    decim: D
    taps: firdes.low_pass(1, samp_rate, 0.4*samp_rate/D, 0.1*samp_rate/D)
    type: ccf
  states: {}
- name: qtgui_freq_sink_con_filtro
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    color1: '"green"'
    ctrlpanel: 'True'
    fc: 99.1e6
    fftsize: '1024'
    name: '"Decimating FIR: con filtro"'
    type: complex
  states: {}
- name: qtgui_freq_sink_original
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: 99.1e6
    fftsize: '1024'
    name: '"Original: 2.4 MS/s"'
    type: complex
  states: {}
- name: qtgui_freq_sink_sin_filtro
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    color1: '"red"'
    ctrlpanel: 'True'
    fc: 99.1e6
    fftsize: '1024'
    name: '"Keep 1 in D: sin filtro"'
    type: complex
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_original, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_freq_sink_sin_filtro, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_con_filtro, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
