options:
  parameters:
    author: ollerenac-uni
    id: lora_recuperar_trama
    title: Recuperación de la trama LoRa
    description: Guarda la trama LoRaWAN en binario y muestra el resultado del CRC físico.
    output_language: python
    generate_options: no_gui
    run_options: run
  states: {}

blocks:
- name: captura_lora
  id: blocks_file_source
  parameters:
    type: complex
    file: ../../output/lorawan-iq/correcto.sigmf-data
    repeat: 'False'
  states: {}
- name: receptor_lora
  id: lora_rx
  parameters:
    samp_rate: '1000000'
    bw: '125000'
    sf: '7'
    impl_head: 'False'
    cr: '1'
    has_crc: 'True'
    pay_len: '255'
    soft_decoding: 'True'
    ldro: '2'
    sync_word: '[0x34]'
    print_rx: '[False,False]'
  states: {}
- name: guardar_trama
  id: blocks_file_sink
  parameters:
    type: byte
    file: ../../output/lorawan-iq/trama_recibida.bin
  states: {}
- name: etiquetas_lora
  id: blocks_tag_debug
  parameters:
    type: byte
    name: CRC LoRa
    filter: frame_info
  states: {}

connections:
- [captura_lora, '0', receptor_lora, '0']
- [receptor_lora, '0', guardar_trama, '0']
- [receptor_lora, '0', etiquetas_lora, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
