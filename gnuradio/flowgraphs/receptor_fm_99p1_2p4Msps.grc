options:
  parameters:
    description: Receptor FM de 99.1 MHz con archivo CU8 por defecto y Soapy RTL-SDR opcional.
    generate_options: qt_gui
    id: receptor_fm_99p1_2p4Msps
    output_language: python
    title: Receptor FM 99.1 MHz — archivo o RTL-SDR
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 99.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.2'
    widget: slider
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    comment: 192 kS/s / 4 = 48 kS/s de audio mono.
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Centra el cero CU8 en 127.5.
    const: '-127.5'
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    comment: Separa I y Q alternados.
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Ruta predeterminada: bytes CU8 I,Q de la captura oficial.'
    file: ../samples/fm_99p1MHz_2p4Msps_g30.cu8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Reconstruye I+jQ.
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normaliza aproximadamente al intervalo -1..1.
    const: 1/127.5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: 'Dos bytes por muestra I/Q: limita el archivo a 2*samp_rate bytes/s.'
    samples_per_second: 2*samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_freq_sink_canal
  id: qtgui_freq_sink_x
  parameters:
    bw: '192000'
    color1: '"green"'
    fc: freq
    fftsize: '1024'
    name: '"Canal: 192 kS/s"'
    type: complex
  states: {}
- name: qtgui_freq_sink_canal_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 192000/4
    color1: '"green"'
    fc: '0'
    fftsize: '1024'
    name: '"Canal: 192 kS/s"'
    type: float
  states: {}
- name: qtgui_freq_sink_rf
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    gui_hint: 0,0,1,1
    name: '"RF: 2.4 MS/s"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_waterfall_sink_rf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    gui_hint: 1,0,1,2
    int_max: '-20'
    int_min: '-100'
    label1: ''''''
    name: '"Waterfall RF: 2.4 MS/s"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 2.4 MS/s × 2/25 = 192 kS/s.
    decim: '25'
    interp: '2'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    comment: 'Alternativa con dongle: activar esta fuente y desactivar los siete bloques CU8.'
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_canal_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_rf, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_rf, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_canal, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_rf, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_rf, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
